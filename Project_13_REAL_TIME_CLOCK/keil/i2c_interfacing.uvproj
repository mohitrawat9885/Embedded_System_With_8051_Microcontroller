# Keil uVision project i2c_interfacing.uvproj, settings and files
target Target 1 (MCS-51)
  device: AT89C51 Microchip
  cpu: IRAM(0-0x7F) IROM(0-0xFFF) CLOCK(24000000)
  output: i2c_interfacing +hex
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ./: delay.c ds1307.c i2c.c lcd.c main.c
