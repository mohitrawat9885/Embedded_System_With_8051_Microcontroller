# Keil uVision project Getting_Byte.uvproj, settings and files
target Target 1 (MCS-51)
  device: AT89C51 Microchip
  cpu: IRAM(0-0x7F) IROM(0-0xFFF) CLOCK(24000000)
  output: Getting_Byte +hex
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ./: Getting_Byte.c
